Commit message: tried to correct lidar position

File: src/rubot_mecanum_description/urdf/rubot_lidar_OK.urdf (robot description, URDF)
Before this commit: robot nexus, 8 links, 7 joints
Joints:
- joint scan_joint: origin xyz=0.111 0.076 0.124 rpy=0 0 0 -> xyz=0.111 0.076 0.124 rpy=0 0 3.14
